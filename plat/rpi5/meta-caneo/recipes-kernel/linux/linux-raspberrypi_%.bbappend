FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://can-peak.cfg"
